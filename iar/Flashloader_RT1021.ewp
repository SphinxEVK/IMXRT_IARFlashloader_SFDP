# IAR project Flashloader_RT1021.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: SPHINX_DAP; CPU_MIMXRT1021DAF5A; NDEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa039
  ICCARM.CCIncludePath2: ..\Framework; ..\Framework\Modified; ..\FSL_Drivers\RT1021; ..\sfud\inc; ..\sfdp\inc; ..\SEGGER\RTT; ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flashloader_RT1021.hex
  ILINK.IlinkOutputFile: Flashloader_RT1021.out
  ILINK.IlinkIcfFile: ..\FlashIMXRT1020_RAM256K.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: device.c Flashloader_IMXRT.c
  group Framework
    ../Framework/: flash_loader.c flash_loader_asm.s
  group FSL_Drivers
    ../FSL_Drivers/RT1021/: clock_config.c fsl_clock.c fsl_common.c fsl_flexspi.c fsl_gpio.c fsl_lpspi.c fsl_lpuart.c
  group SFDP/cfg
    ../sfdp/inc/: sfdp_cfg.h
  group SFDP/port
    ../sfdp/port/: sfdp_port.c
  group SFDP/src
    ../sfdp/src/: sfdp.c
