# IAR project Flashloader.ewp, settings and files
configuration RT1052_SphinxEVK (ARM)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: SPHINX_EVK; CPU_MIMXRT1052CVL5B; NDEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa039
  ICCARM.CCIncludePath2: ..\Framework; ..\Framework\Modified; ..\FSL_Drivers; ..\sfud\inc; ..\sfdp\inc; ..\SEGGER\RTT; ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flashloader.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: ..\FlashIMXRT1050_RAM512K.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ../: device.c Flashloader_IMXRT.c
  group FSL_Drivers
    ../FSL_Drivers/: clock_config.c fsl_clock.c fsl_common.c fsl_flexspi.c fsl_lpspi.c fsl_lpuart.c
  group Framework
    ../Framework/: flash_loader.c flash_loader_asm.s
  group SFDP/cfg
    ../sfdp/inc/: sfdp_cfg.h
  group SFDP/port
    ../sfdp/port/: sfdp_port.c
  group SFDP/src
    ../sfdp/src/: sfdp.c
