<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Flashloader_RT1021.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Flashloader_RT1052.ewp</path>
    </project>
    <batchBuild />
</workspace>
