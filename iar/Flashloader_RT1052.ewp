# IAR project Flashloader_RT1052.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: SPHINX_EVK; CPU_MIMXRT1052CVL5B; NDEBUG
  ICCARM.CCDiagSuppress: Pa082,Pa039
  ICCARM.CCIncludePath2: ..\Cmbacktrace; ..\Framework; ..\Framework\Modified; ..\FSL_Drivers\RT1052; ..\sfud\inc; ..\sfdp\inc; ..\SEGGER\RTT; ..\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flashloader_RT1052.hex
  postbuild: cmd /c postbuild.bat
  ILINK.IlinkOutputFile: Flashloader_RT1052.out
  ILINK.IlinkIcfFile: ..\FlashIMXRT1050_RAM512K.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: device.c Flashloader_IMXRT.c isr.c
  group Cmbacktrace
    ../Cmbacktrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../Cmbacktrace/fault_handler/iar/: cmb_fault.S
  group Framework
    ../Framework/: flash_loader.c flash_loader_asm.s
  group FSL_Drivers
    ../FSL_Drivers/RT1052/: clock_config.c fsl_clock.c fsl_common.c fsl_flexspi.c fsl_gpio.c fsl_lpspi.c fsl_lpuart.c
  group SFDP/cfg
    ../sfdp/inc/: sfdp_cfg.h
  group SFDP/port
    ../sfdp/port/: sfdp_port.c
  group SFDP/src
    ../sfdp/src/: sfdp.c
